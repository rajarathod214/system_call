## kernel/Kconfig.myhello
```kconfig
config MYHELLO
	bool "print my hello is running"
	default y
	help
		This is print my hello is running
```
